# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC89E58 Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x7FFF) CLOCK(45000000)
  output: My_132Code_v1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c other.c CPLD.c LCM.c EPROM.c Interrupt.c RS232.c Input.c error.c Motor.c Music.c
